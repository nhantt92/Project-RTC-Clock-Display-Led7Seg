# IAR project RTC_FW.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\Libraries\STM8S_StdPeriph_Driver\inc; ..\User\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RTC_FW.hex
  ILINK.IlinkOutputFile: RTC_FW.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group lib
    ../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim4.c
  group user
    ../User/src/: display.c DS1307.c key.c main.c stm8s_delay.c stm8s_it.c SW_I2C.c timerTick.c
